# Keil uVision project ble_simple_peripheral.uvproj, settings and files
target ble_simple_peripheral (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ble_simple_peripheral
  AfterMake: fromelf.exe  --bin -o ble_simple_peripheral.bin  Objects/ble_simple_peripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\components\ble\include;..\..\..\components\driver\include;..\..\..\components\modules\os\include;..\..\..\components\modules\sys\include;..\..\..\components\modules\platform\include;..\..\..\components\modules\common\include;..\..\..\components\modules\lowpow\include;..\..\..\components\modules\button;..\..\..\components\ble\include\gap;..\..\..\components\ble\include\gatt;..\..\..\components\ble\include\mesh;..\..\..\components\ble\profiles\ble_ota;..\code;..\..\..\components\ble\profiles\ble_simple_profile
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x20000000 size 0x80000
  memory RVCT7: RAM 0x40000000 size 0x4000
  memory RVCT8: RAM 0x500f8888 size 0x100
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ..\..\..\components\ble\library\syscall.txt --entry=app_main --keep=_jump_table --datacompressor=off
  group application
    ../code/: proj_main.c ble_simple_peripheral.c ble_simple_peripheral.h user_task.c
    ../../../components/modules/button/: button.c
  group profiles
    ../../../components/ble/profiles/ble_simple_profile/: simple_gatt_profile.c simple_gatt_profile.h
  group driver
    ../../../components/driver/: driver_codec.c driver_efuse.c driver_i2s.c driver_iic.c driver_keyscan.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_ssp.c driver_timer.c driver_wdt.c driver_rtc.c
  group platform
    ../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../../../components/modules/patch/: patch.c
  group lib
    ../../../components/ble/library/: fr8010h_stack.lib

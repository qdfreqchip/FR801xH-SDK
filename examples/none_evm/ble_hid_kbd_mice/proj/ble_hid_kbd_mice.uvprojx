# Keil uVision project ble_hid_kbd_mice.uvprojx, settings and files
target ble_hid_kbd_mice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_5_stack
  AfterMake: fromelf.exe  --text  -c -o host_app.txt  Objects/ble_5_stack.axf
  AfterMake: fromelf.exe  --bin -o host_app.bin  Objects/ble_5_stack.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_ADV_MEM_ALLOOC_NEW,CFG_SIMPLE_PRINTF
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_ota;..\code;..\..\..\..\components\ble\profiles\ble_dev_info;..\..\..\..\components\ble\profiles\ble_batt;..\..\..\..\components\ble\profiles\ble_hid
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0_host_app.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c ble_hid_kbd_mice.c ble_hid_kbd_mice.h
  group profiles
    ../../../../components/ble/profiles/ble_batt/: batt_service.c
    ../../../../components/ble/profiles/ble_dev_info/: dev_info_service.c
    ../../../../components/ble/profiles/ble_hid/: hid_service.c
    ../../../../components/ble/profiles/ble_ota/: ota.c ota_service.c
  group ble_lib_plf
    ../../../../components/modules/platform/source/: app_boot_vectors.s core_cm3_isr.c
  group ble_lib_patch
    ../../../../components/modules/patch/: patch.c
    ../../../../components/ble/library/: fr8010h_stack.lib
  group driver
    ../../../../components/driver/: driver_iic.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_pwm.c driver_rtc.c driver_ssp.c driver_timer.c driver_uart.c driver_wdt.c driver_adc.c driver_codec.c driver_efuse.c driver_exti.c driver_flash_ssp.c driver_i2s.c driver_keyscan.c
software components: CMSIS:CORE 5.3.0

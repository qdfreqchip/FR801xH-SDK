# Keil uVision project ble_mesh.uvproj, settings and files
target ble_mesh (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ble_mesh
  AfterMake: fromelf.exe  --bin -o ble_mesh.bin  Objects/ble_mesh.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\components\ble\include;..\..\..\components\driver\include;..\..\..\components\modules\os\include;..\..\..\components\modules\sys\include;..\..\..\components\modules\platform\include;..\..\..\components\modules\common\include;..\..\..\components\modules\lowpow\include;..\..\..\components\modules\button;..\..\..\components\ble\include\gap;..\..\..\components\ble\include\gatt;..\..\..\components\ble\include\mesh;..\..\..\components\ble\profiles\ble_ota;..\code
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ..\..\..\components\ble\library\syscall.txt --entry=app_main --keep=_jump_table --datacompressor=off
  group application
    ../code/: ali_mesh_led.c app_at.c prf_server.c proj_main.c user_task.c
    ../../../components/modules/button/: button.c
  group driver
    ../../../components/driver/: driver_codec.c driver_efuse.c driver_i2s.c driver_iic.c driver_keyscan.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_ssp.c driver_timer.c driver_wdt.c driver_rtc.c
  group platform
    ../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../../../components/modules/patch/: patch.c
  group lib
    ../../../components/ble/library/: fr8010h_stack.lib
